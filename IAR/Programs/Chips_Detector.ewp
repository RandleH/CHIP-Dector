# IAR project Chips_Detector.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Libraries\Drivers; ..\..\Libraries\startup; ..\..\Libraries\startup\DeviceSupport; ..\..\Libraries\startup\CoreSupport; ..\..\Libraries\Devices\inc; ..\..\Users; ..\..\Libraries\Tools\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: Chips_Detector.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\NXP\MK60xN512_10.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group Devices/inc
    ../../Libraries/Devices/inc/: key_board.h LCD1602.h LED.h
  group Devices/src
    ../../Libraries/Devices/src/: key_board.c LCD1602.c LED.c
  group Drivers/inc
    ../../Libraries/Drivers/: CHIPs_Lib.h common.h debug.h IC_Test.h information.h SystickDelay.h
    ../../Libraries/startup/DeviceSupport/: MK60D10.h
  group Drivers/src
    ../../Libraries/Drivers/: CHIPs_Lib.c debug.cpp IC_Test.cpp information.cpp SystickDelay.c
  group Startup
    ../../Libraries/startup/CoreSupport/: core_cm0plus.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
    ../../Libraries/startup/DeviceSupport/IAR-ARM/: startup_MK60D10.s
    ../../Libraries/startup/DeviceSupport/: system_MK60D10.c system_MK60D10.h
  group Tools/inc
    ../../Libraries/Tools/inc/: Num_Convert.h
  group Tools/src
    ../../Libraries/Tools/src/: Num_Convert.c
  group Users/inc
    ../../Users/: headfiles.h
  group Users/src
    ../../Users/: isr.cpp main.cpp
