# Keil uVision project CHIPs_Dector.uvprojx, settings and files
target MK60DN512 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: CHIPs_Dector
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Libraries\Devices\inc;..\Libraries\Drivers;..\Libraries\startup\CoreSupport;..\Libraries\Tools\inc;..\Users
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Devices
    ../Libraries/Devices/src/: KEY.c LCD1602.c LED.c
  group Drivers
    ../Libraries/Drivers/: IC_Test.c SystickDelay.c
  group Startup
    ../Libraries/startup/DeviceSupport/: system_MK60D10.c MK60D10.h
    ../Libraries/startup/DeviceSupport/MDK-ARM/: startup_MK60D10.s
    ../Libraries/startup/CoreSupport/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group Users
    ../Users/: headfiles.h isr.c main.c
  group Tools
    ../Libraries/Tools/src/: Num_Convert.c
